# Keil uVision project HSE_LSE_SYS32Mhz_SPI.uvprojx, settings and files
target HSE_LSE_SYS32Mhz_SPI (6120000::V6.12::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IROM(0x08000000-0x807FFFF) IRAM2(0x20030000-0x200323FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: HSE_LSE_SYS32Mhz_SPI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB55xx
  c include: ../Core/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x2400
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c rtc.c spi.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
software components: CMSIS:CORE 5.2.0
